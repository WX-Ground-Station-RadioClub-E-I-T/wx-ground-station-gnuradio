options:
  parameters:
    author: pepassaco
    category: Custom
    generate_options: no_gui
    id: WXsat_APT_no_gui
    output_language: python
    title: Desmodulador FM para NOAA
  states: {}

blocks:
- name: af_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: antenna
  id: variable
  parameters:
    value: '"RX"'
  states: {}
- name: bpf_hp
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: bpf_lp
  id: variable
  parameters:
    value: '500'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: '40'
  states: {}
- name: f_real
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fcd_freq
  id: variable
  parameters:
    value: '137100000'
  states: {}
- name: lna_gain_0
  id: variable
  parameters:
    value: '30'
  states: {}
- name: prefix
  id: variable
  parameters:
    value: '"/home/tallerine/sdr-apt/wav/"'
  states: {}
- name: recfile
  id: variable
  parameters:
    value: '"/src/prueba1.wav"'
  states: {}
- name: recfile2
  id: variable
  parameters:
    value: '"/src/prueba2.wav"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: variable_qtgui_label_0
  id: variable
  parameters:
    value: fcd_freq
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fcd_freq*(1-f_real)
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    comment: Demodulación FM
    quad_rate: '96000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: bpf_hp
    interp: '1'
    low_cutoff_freq: bpf_lp
    samp_rate: '48000'
    type: interp_fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '5'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '11'
    max_iter: '4000'
    scale: 1/11.
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: af_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    comment: Registro de archivo de audio
    file: recfile
    samp_rate: '20800'
  states: {}
- name: blocks_wavfile_sink_1_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: recfile2
    samp_rate: '4160'
  states: {}
- name: doppler_MsgPairToVar_0
  id: doppler_MsgPairToVar
  parameters:
    target: freq_real
  states: {}
- name: doppler_doppler_0
  id: doppler_doppler
  parameters:
    gnd_alt: '666'
    gnd_lat: '40.4167'
    gnd_lon: '-3.70325'
    refresh_period: '0.1'
    sat_id: ISS
    tle_file: ''
    verbose: 'False'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency of the satellite
    type: intx
    value: '1371000000'
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    num_taps: '5'
    win: firdes.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2000'
    decim: '1'
    gain: '10'
    samp_rate: '20800'
    type: fir_filter_fff
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff*1000
    decim: '1'
    gain: '30'
    samp_rate: '96000'
    type: fir_filter_ccf
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Bajo tasa de muestreo
    decim: samp_rate
    interp: '96000'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    comment: Cambio tasa de muestreo
    decim: '48000'
    interp: '20800'
    taps: ''
    type: fff
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: antenna
    args: '"remote=192.168.0.10:55132, remote:driver=airspyhf"'
    balance0: '0'
    center_freq0: freq
    comment: |-
      Use SoapySDRServer --bind="0.0.0.0:1234"
      or similar to the remote server
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dev: driver=remote
    devname: custom
    overall_gain0: lna_gain_0
    samp_rate: samp_rate
    sdrplay_biastee: 'True'
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0_0, '0', band_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_wavfile_sink_0_0, '0']
- [band_pass_filter_0, '0', hilbert_fc_0_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_wavfile_sink_1_0, '0']
- [blocks_moving_average_xx_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [doppler_doppler_0, dop_factor, doppler_MsgPairToVar_0, inpair]
- [hilbert_fc_0_0, '0', blocks_complex_to_mag_0_0, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [low_pass_filter_1_0, '0', analog_wfm_rcv_0_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_1_0, '0']
- [rational_resampler_xxx_0_0_0, '0', low_pass_filter_0_0, '0']
- [soapy_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
